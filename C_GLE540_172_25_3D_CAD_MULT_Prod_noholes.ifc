Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:09:33
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:09:33 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{4F59072C-AC06-4247-91E5-28DF77DB2F83}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:09:33 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:09:33 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:09:33 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Remove Holes\IFC\C_GLE540_172_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Graphics - Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Weight: 1; Line Pattern: -3000010; Color: 0

# IfcBuildingElementProxy: C_GLE540_172_25_3D_CAD_MULT_Prod_noholes, C_GLE540_172_25_3D_CAD_MULT_Prod_noholes:C_GLE540_172_25_3D_CAD_MULT_Prod_noholes:115719
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00430856 ft3
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/172/2.5
Identity Data - Model: GLE540/172/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; OmniClass Title: Wood Connectors; Name: GLE540/172/2.5; Product Type: Joist hanger; URL: www.strongtie.eu; Model ID: 0091885215669378180997711724626713274103; ObjectType: GLE540/172/2.5; UniClass Number: Pr_20_29_31_44
General - Reference: GLE540/172/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 0.95
Materials and Finishes - Product Material: Galvanised
