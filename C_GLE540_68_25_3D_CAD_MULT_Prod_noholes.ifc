Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:29:05
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:29:05 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{6576EF4E-35A2-4573-A179-925ABE3B5699}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:29:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:29:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:29:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Remove Holes\RFA 3D\GLE540_68_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Color: 0; Line Weight: 1; Line Pattern: -3000010; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GLE540_68_25, GLE540_68_25:GLE540_68_25:105671
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00432535 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/68/2.5
Identity Data - OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; Description: Joist hanger; ObjectType: GLE540/68/2.5; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; URL: www.strongtie.eu; Model ID: 0238633509286448766558399637212397222310; Name: GLE540/68/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE540/68/2.5; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE540/68/2.5; Density: 0.922; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
