Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:09:39
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:09:39 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{8D37301C-6168-49CF-AD08-3E1A635F5BB7}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:09:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:09:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:09:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Remove Holes\IFC\C_GLE540_194_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1

# IfcBuildingElementProxy: C_GLE540_194_25_3D_CAD_MULT_Prod_noholes, C_GLE540_194_25_3D_CAD_MULT_Prod_noholes:C_GLE540_194_25_3D_CAD_MULT_Prod_noholes:122627
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00430856 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE540/194/2.5
Identity Data - Provide Feedback: mailto:EUdrawings@strongtie.com; Product Type: Joist hanger; Model ID: 0091885215669378180997711724626713274103; Name: GLE540/194/2.5; ObjectType: GLE540/194/2.5; OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Copyright: ©Simpson Strong-Tie; Model: GLE540/194/2.5; OmniClass Number: 23.20.40.11.24.14
General - Reference: GLE540/194/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 0.95
Materials and Finishes - Product Material: Galvanised
